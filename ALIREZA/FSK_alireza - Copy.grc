<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrier</value></param>
<param><key>value</key><value>deltaF</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deltaF</value></param>
<param><key>value</key><value>samp_rate/(sps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>e1</value></param>
<param><key>value</key><value>sum([np.power(np.cos(2 * np.pi * float(carrier) * float(i) / float(samp_rate)), 2) for i in range(sps)])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>e2</value></param>
<param><key>value</key><value>sum([np.power(np.cos(2 * np.pi * (float(carrier) + deltaF) * float(i) / float(samp_rate)), 2) for i in range(sps)])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_data</value></param>
<param><key>value</key><value>1600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_idle</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>E:\my.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>list( ord(i) for i in 'Alireza KH...')</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>carier</key><value>carrier</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.interp_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, sps=8, carier=2000 , samp_rate=32000):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.interp_block.__init__(
            self,
            name='fsk_mod_alireza',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32,np.float32],
            interp = int(sps)
            
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.sps = sps
        self.T = float(sps)/float(samp_rate)
        self.sep_freq = float(samp_rate /(sps) )

        self.first_I = [np.cos(2 * np.pi * (float(carier)) * float(i) / float(samp_rate) ) for i in range(sps) ]
        self.first_Q = [np.sin(2 * np.pi * (float(carier)) * float(i) / float(samp_rate) ) for i in range(sps) ]
               
        self.second_I = [np.cos(2 * np.pi * (float(carier) + self.sep_freq ) * float(i) /float(samp_rate)) for i in range(sps) ]
        self.second_Q = [np.sin(2 * np.pi * (float(carier) + self.sep_freq ) * float(i) /float(samp_rate)) for i in range(sps) ]
    
    def work(self, input_items, output_items):

        output_items[0][:] =[self.first_I[j] if input_items[0][i] == 0 else self.second_I[j]
        for i in range( len(input_items[0])) for j in range(self.sps) ]


        output_items[1][:] =[self.first_Q[j] if input_items[0][i] == 0 else self.second_Q[j]
        for i in range( len(input_items[0])) for j in range(self.sps) ]


        return len(output_items[0]) 
        #return ( len(output_items[1]) )







</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr

class blk(gr.interp_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, one = "01", zero = "00"):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.interp_block.__init__(
            self,
            name='Binary Coder',   # will show up in GRC
            in_sig=[np.uint8],
            out_sig=[np.uint8],
            interp = len(one)
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.one = one
        self.zero = zero
        self.len = len(one)

    def work(self, input_items, output_items):
        """example: multiply with constant"""

        output_items[0][:] = np.array([np.uint8(self.one[i % self.len]) if input_items[0][i / self.len] == 1 else np.uint8(self.zero[i % self.len]) for i in range(len(output_items[0]))])
        #print(len(input_items[0]))
        return len(output_items[0])
</value></param>
<param><key>one</key><value>'01'</value></param>
<param><key>zero</key><value>'00'</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, len_packet=107,samp_per_sym =12,num_idle=7):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='Detect Preamble',   # will show up in GRC
            in_sig=[np.float32,np.float32],
            out_sig=[np.float32]
        )

        self.set_output_multiple( samp_per_sym * len_packet )


        self.len_packet = len_packet
        self.samp_per_sym = samp_per_sym
        self.num_idle = num_idle
        self.key = pmt.intern("start")
        self.value = pmt.intern("100")
        self.value1 = pmt.intern("999")

        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

    def forecast(self, noutput_items, ninput_items_required):
        ninput_items_required[0] = noutput_items + self.len_packet * self.samp_per_sym
        ninput_items_required[1] = noutput_items + self.len_packet * self.samp_per_sym



    def general_work(self, input_items, output_items):
        lenin = int(len(output_items[0]))
        index =[]
        temp = []
        for i in range( lenin -1 ):               
            if( input_items[1][i] &gt;0.98 ):
                if( (input_items[1][i] &gt;= input_items[1][i-1]) and (input_items[1][i] &gt; input_items[1][i+1] ) ):
                    if  ( (len(index) !=0 ) and ( (i-index[-1]) &lt; self.samp_per_sym * self.num_idle) ):
                        index.remove( index[-1] )
                        index.append( i )
                    else:
                        index.append(i)
                    
           
        for i in index:
            self.add_item_tag(0, self.nitems_written(0) + i, self.key, self.value)

        for i in range(len(index)-1):
            a=(index[i+1]-index[i])/self.samp_per_sym
            if(a != self.len_packet):
                print(a)
        #print('jjj')
        output_items[0][:]=[ input_items[0][i] for i in range( lenin ) ]

        self.consume(0, lenin)
        self.consume(1, lenin)

        return lenin

        
        

    '''
        for k in range(len(index)):

            if(k==0):
                self.add_item_tag(0, self.nitems_written(0) + index[k], self.key, self.value)
            else:
                aa=index[k]-index[k-1]
                if( int(aa/(self.samp_per_sym)) == self.len_packet ):
                    self.add_item_tag(0, self.nitems_written(0) + index[k], self.key, self.value)
                else:
                    index.remove( index[k] )
                    #self.add_item_tag(0, self.nitems_written(0) + index[k], self.key, self.value)
                    #self.add_item_tag(0, self.nitems_written(0) + i, self.key, self.value1)
'''
</value></param>
<param><key>len_packet</key><value>len_data + num_idle</value></param>
<param><key>num_idle</key><value>num_idle</value></param>
<param><key>samp_per_sym</key><value>1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self,preamble="1111111",num_packed=207):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='Addind Preamble',   # will show up in GRC
            in_sig=[np.uint8],
            out_sig=[np.uint8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        ''' set size of output'''
        self.set_output_multiple(num_packed)

        self.pre = map(np.uint8,preamble)
        self.num_pre = len(preamble)

        self.num_packed = num_packed
        self.num_data = num_packed - self.num_pre

    def forecast(self, noutput_items, ninput_items_required):
           ninput_items_required[0] = self.len_input_func(noutput_items)


    def general_work(self, input_items, output_items):

        num = int( self.len_input_func( len(output_items[0]) ) / self.num_data )
        #print(num)
        output_items[0][:] = [self.pre[j] if j&lt;self.num_pre else 
        input_items[0][i* self.num_data + ( j - self.num_pre ) ] for i in range(num)
        for j in range(self.num_packed)   ]

        self.consume(0, self.len_input_func( len(output_items[0]) )  )
        return len(output_items[0])

  
    def len_input_func(self, noutput):
        ''' set size of input using size of output ''' 
        n=int(noutput / self.num_packed )
        return (noutput - n * self.num_pre )






</value></param>
<param><key>num_packed</key><value>len_data + num_idle</value></param>
<param><key>preamble</key><value>''.join( ['1' for i in range(num_idle)] )</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2_1_0</value></param>
<param><key>begin</key><value>sps-1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, decim = 1, begin = 0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.decim_block.__init__(
            self,
            name='Decimator',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32],
            decim = int(decim)
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.decim = decim
        self.begin = begin

    def work(self, input_items, output_items):
        """Decimator"""
        index = [int(self.begin + i * self.decim) for i in range(len(output_items[0]))]
        output_items[0][:] = np.array([input_items[0][i] for i in index])

        return len(output_items[0])

</value></param>
<param><key>decim</key><value>sps</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2_1_1</value></param>
<param><key>begin</key><value>sps-1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, decim = 1, begin = 0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.decim_block.__init__(
            self,
            name='Decimator',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32],
            decim = int(decim)
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.decim = decim
        self.begin = begin

    def work(self, input_items, output_items):
        """Decimator"""
        index = [int(self.begin + i * self.decim) for i in range(len(output_items[0]))]
        output_items[0][:] = np.array([input_items[0][i] for i in index])

        return len(output_items[0])

</value></param>
<param><key>decim</key><value>sps</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_3</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, in0 = 0, in1 = 1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Argmax',   # will show up in GRC
            in_sig=[np.float32, np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.in0 = in0
        self.in1 = in1

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        output_items[0][:] = [self.in0 if input_items[0][i] &gt;= input_items[1][i] else
        self.in1 for i in range(len(input_items[0]))]

        return len(output_items[0])
</value></param>
<param><key>in0</key><value>0</value></param>
<param><key>in1</key><value>1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_4</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt

class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self,len_packet=107,num_idle=7,sps =12 ):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='remove preamble',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )

        self.set_output_multiple(sps*len_packet - sps*num_idle)

        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.len_packet = len_packet
        self.num_idle = num_idle
        self.len_data = len_packet - num_idle
        self.sps = sps
    def forecast(self, noutput_items, ninput_items_required):
        ninput_items_required[0] = self.calc_input_size(noutput_items)
        


    def general_work(self, input_items, output_items):
        #lenin = int(len(output_items[0]))
        #num = int(lenin / self.len_data)


        len_out = len(output_items[0])
        lenin = self.calc_input_size(len_out)
        num = int(len_out / (self.len_data * self.sps ))


        tags = self.get_tags_in_window(0, 0, lenin)
        index = np.array([i.offset - self.nitems_read(0) for i in tags])
        len_index = len(index)
        out_temp = []

        #for j in range( len_index - 1 ):
        #    print( (index[j+1]-index[j])*1.0/self.sps )
    
        #print('YYY') 

        num1 =min(len_index-1,num)        
        for j in range( num1 ):
            for i in range( self.len_data *self.sps):
                out_temp.append( input_items[0][ index[j]+i+1] )

        for i in range( num1 * self.len_data * self.sps ):
            output_items[0][i]=out_temp[i]
        #output_items[0][:] = [.5 for i in range(len(output_items[0]))]
        #print(len_index-1)
        #print(num)
        #print(num1)
        #print('rrr')

        self.consume(0,  num1 * self.len_data * self.sps )

        return ( num1 * self.len_data * self.sps )


    def calc_input_size(self, output_size):
        n = int(output_size /(self.sps* self.len_data) )
        return output_size + n * self.sps * self.num_idle
</value></param>
<param><key>len_packet</key><value>len_data + num_idle</value></param>
<param><key>num_idle</key><value>num_idle</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_5</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self,one='01',zero='00'):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.decim_block.__init__(
            self,
            name='Binary Decoder',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32],
            decim = len(one)
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).


    def work(self, input_items, output_items):
        """example: multiply with constant"""
        '''out =[]
        for i in range( len(input_items[0])-1 ):
            if( input_items[0][i] == input_items[0][i+1] ):
                out.append( 1 )
            else:
                out.append( 0 )
            i+=1
        output_items[0] = out'''
        #print(len(input_items[0]))
        output_items[0][:] = [0 if (input_items[0][2*i] ==input_items[0][2*i+1]) else 1   for i in range( int(len(input_items[0])/2) ) ]
        return len(output_items[0])






</value></param>
<param><key>one</key><value>'01'</value></param>
<param><key>zero</key><value>'00'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[1.0 / float(num_idle) for i in range(num_idle) ]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[np.exp(2j * np.pi  *  (float(carrier)+ deltaF) * float(i) /float(samp_rate))/e1 for i in range(sps)]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_1_2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[np.exp(2j* np.pi  * float(carrier) * float(i) /float(samp_rate))/e1 for i in range(sps)]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>3</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>5000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>3</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>512</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>3</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>512</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>epy_block_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>epy_block_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>interp_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>interp_fir_filter_xxx_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>epy_block_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_0_1</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>epy_block_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2_1_1</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2_1_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2_1_1</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_3</source_block_id><sink_block_id>epy_block_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_4</source_block_id><sink_block_id>epy_block_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_5</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_5</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_1_2</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
